LOAD_ROM_1  0x000000 0x2000
{
	ISP_HID.bin  0x000000 0x2000
	{
		startup_NUC121.o (RESET, +FIRST)
        .ANY (+RO)
	}
	
	SRAM  0x20000000 0x2000
	{
		* (+RW, +ZI)
	}
}

